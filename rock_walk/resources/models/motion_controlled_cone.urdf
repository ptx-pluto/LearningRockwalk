Commit message: add new geometry

File: rock_walk/resources/models/motion_controlled_cone.urdf (robot description, URDF)
Before this commit: robot LargeConeControl, 8 links, 7 joints
Links:
- link cone: geometry collision mesh filename=mesh/half_cy.obj; visual mesh filename=mesh/half_cy.obj
