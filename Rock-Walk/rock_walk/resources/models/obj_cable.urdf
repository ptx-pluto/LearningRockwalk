Commit message: minor

File: Rock-Walk/rock_walk/resources/models/obj_cable.urdf (robot description, URDF)
Before this commit: robot ObjectCableSystem, 8 links, 7 joints
Joints:
- joint joint_cable_tether: limit lower=0. upper=0.5 -> lower=-1.0 upper=1.0; origin xyz=0 0 -1 -> xyz=0 0.3 -1.5
